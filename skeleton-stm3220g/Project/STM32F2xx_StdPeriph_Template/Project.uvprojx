# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG_EVAL
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM322xG_EVAL, STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\STM32F2xx_StdPeriph_Template;..\..\FreeRTOS;..\..\Utilities\STM32_Audio\Common;..\..\Utilities\STM32_Audio\STM322xG_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group System
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
    ./: system_stm32f2xx.c fft.c graph.c color.c
    ../../Utilities/STM32_Audio/STM322xG_EVAL/: stm322xg_audio_recorder.c
    ../../FreeRTOS/: FreeRTOSConfig.h
  group Application
    ./: main.c global.h fft_test.c
  group STM32F2xx_StdPeriph_Driver
    ../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_exti.c stm32f2xx_adc.c
  group FreeRTOS
    ../../FreeRTOS/: list.c port.c queue.c tasks.c timers.c heap_1.c
  group Utilities
    ../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_ioe.c stm322xg_eval_lcd.c
    ./: LCD.c TS.c
software components: CMSIS:CORE 4.3.0
